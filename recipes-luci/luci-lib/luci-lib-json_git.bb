DESCRIPTION = "Web user interface for embedded devices - JSON library"

MODS="libs/json"

include ../luci.inc

PR = "r0" 
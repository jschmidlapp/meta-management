DESCRIPTION = "Web user interface for embedded devices - ipkg/opkg call abstraction library"

MODS="libs/ipkg"

include ../luci.inc

PR = "r0" 
DESCRIPTION = "Web user interface for embedded devices - CGI gateway behind existing webserver"

MODS="libs/sgi-cgi"

include ../luci.inc

PR = "r0" 


DESCRIPTION = "Web user interface for embedded devices - RSA/X.509 key generator library"

MODS="libs/px5g"

include ../luci.inc

RDEPENDS += "luci-lib-nixio"

PR = "r0" 


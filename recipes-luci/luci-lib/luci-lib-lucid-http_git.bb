DESCRIPTION = "Web user interface for embedded devices - LuCId HTTP backend library"

MODS="libs/lucid-http"

include ../luci.inc

RDEPENDS += "luci-lib-lucid"

PR = "r0" 
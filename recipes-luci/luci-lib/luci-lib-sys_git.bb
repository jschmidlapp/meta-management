DESCRIPTION = "Web user interface for embedded devices - Linux/POSIX system library"

include ../luci.inc

MODS="libs/sys"

PR = "r2" 


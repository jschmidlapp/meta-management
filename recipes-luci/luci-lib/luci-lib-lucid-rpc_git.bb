DESCRIPTION = "Web user interface for embedded devices - LuCId RPC backend library"

MODS="libs/lucid-rpc"

include ../luci.inc

RDEPENDS += "luci-lib-lucid"

PR = "r0" 
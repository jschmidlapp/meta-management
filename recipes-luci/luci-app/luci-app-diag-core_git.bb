DESCRIPTION = "Web user interface for embedded devices - diagnostics tool (core)"

MODS="applications/diag-core"
I18N_MOD ?= "diag_core"

include ../luci.inc

PR = "r0" 
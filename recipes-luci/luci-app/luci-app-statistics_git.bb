DESCRIPTION = "Web user interface for embedded devices - statistics application"

MODS="applications/statistics"
I18N_MOD ?= "rrdtool"

include ../luci.inc

#TODO depends

PR = "r0" 
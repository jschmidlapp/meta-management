DESCRIPTION = "Web user interface for embedded devices - OpenWRT Theme"

MODS="themes/openwrt"

include ../luci.inc

RDEPENDS += "luci-theme-base"

PR = "r0"
DESCRIPTION = "Web user interface for embedded devices - common base for all themes"

MODS="themes/base"

include ../luci.inc

PR = "r0"
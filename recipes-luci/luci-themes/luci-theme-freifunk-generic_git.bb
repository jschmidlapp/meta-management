DESCRIPTION = "Web user interface for embedded devices - Freifunk Generic Theme"

MODS="themes/freifunk-generic"

include ../luci.inc

DEPENDS += "luci-theme-base"

PR = "r0"  